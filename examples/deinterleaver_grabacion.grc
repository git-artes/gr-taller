<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hor</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>orden</value></param>
<param><key>value</key><value>[171,  68,   4,  74,  41,   7, 110, 117, 174, 102, 158,  17,  59,
       141, 159, 112,  46, 129, 182, 131,  50, 101,  64, 138, 170,  77,
       125, 181,  92,  27,  65,  86,   8,  73, 123, 144, 198,  87,  20,
        62, 108,  28,  94, 151,  13, 113, 165, 127,  39,  89,  11, 152,
       120, 186,  56, 109, 164, 114,  53, 155, 107,  99, 154, 169, 153,
        40,  79, 128,  32,  29,  47, 193,  81, 195,  97,  93, 140,  23,
        35,  33,  98, 132,  54, 142, 126,  66, 191, 134, 133,  42,  76,
       161,  61, 177,  71,  19,  36, 162,  58, 175,  45, 147,  48, 146,
        80, 160,  44,  60,  12,  96, 196,  49, 116,   3, 183, 187,  88,
        10,  16, 115, 197,  26,  57,  25, 143, 122, 137, 199,   9,  38,
        24, 173, 105,  31,  18,  91, 172, 121, 111, 104, 192,   2, 180,
       119,  70,  67, 176, 148,  82,  84, 136, 130, 179,  69,   0,  75,
       168,  63,  37,  43,   6,  21, 163, 100,  55,  22,  78,  83, 194,
       157, 178, 103,  52,  95, 139, 166, 184,  90,  72,  30, 156,  85,
       167,  34,   5, 189,   1,  14, 106, 124, 145, 185, 188, 150,  51,
       149, 135, 118, 190,  15]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ver</value></param>
<param><key>value</key><value>172</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>hor</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/flarroca/ownCloud/facultad/cursos/taller_gnuradio/gr-taller/examples/grabacion.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>hor</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>hor</value></param>
</block>
<block>
<key>taller_deinterleaver</key>
<param><key>id</key><value>taller_deinterleaver_0</value></param>
<param><key>orden</key><value>orden</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0</value></param>
<param><key>display_height</key><value>ver</value></param>
<param><key>display_width</key><value>hor</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>ver</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>hor</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>video_sdl_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>taller_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>taller_deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
