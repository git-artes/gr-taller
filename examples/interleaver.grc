<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hor</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>orden</value></param>
<param><key>value</key><value>[171,  68,   4,  74,  41,   7, 110, 117, 174, 102, 158,  17,  59,
       141, 159, 112,  46, 129, 182, 131,  50, 101,  64, 138, 170,  77,
       125, 181,  92,  27,  65,  86,   8,  73, 123, 144, 198,  87,  20,
        62, 108,  28,  94, 151,  13, 113, 165, 127,  39,  89,  11, 152,
       120, 186,  56, 109, 164, 114,  53, 155, 107,  99, 154, 169, 153,
        40,  79, 128,  32,  29,  47, 193,  81, 195,  97,  93, 140,  23,
        35,  33,  98, 132,  54, 142, 126,  66, 191, 134, 133,  42,  76,
       161,  61, 177,  71,  19,  36, 162,  58, 175,  45, 147,  48, 146,
        80, 160,  44,  60,  12,  96, 196,  49, 116,   3, 183, 187,  88,
        10,  16, 115, 197,  26,  57,  25, 143, 122, 137, 199,   9,  38,
        24, 173, 105,  31,  18,  91, 172, 121, 111, 104, 192,   2, 180,
       119,  70,  67, 176, 148,  82,  84, 136, 130, 179,  69,   0,  75,
       168,  63,  37,  43,   6,  21, 163, 100,  55,  22,  78,  83, 194,
       157, 178, 103,  52,  95, 139, 166, 184,  90,  72,  30, 156,  85,
       167,  34,   5, 189,   1,  14, 106, 124, 145, 185, 188, 150,  51,
       149, 135, 118, 190,  15]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var</value></param>
<param><key>value</key><value>100</value></param>
<param><key>label</key><value>var</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ver</value></param>
<param><key>value</key><value>172</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>var</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/flarroca/ownCloud/facultad/cursos/taller_gnuradio/gr-taller/examples/grabacion.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>hor</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>3</value></param>
<param><key>vector</key><value>range(3)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>hor</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>9</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>taller_deinterleaver</key>
<param><key>id</key><value>taller_deinterleaver_0</value></param>
<param><key>orden</key><value>orden</value></param>
</block>
<block>
<key>taller_interleaver</key>
<param><key>id</key><value>taller_interleaver_0</value></param>
<param><key>orden</key><value>orden</value></param>
</block>
<block>
<key>tempest_image_source</key>
<param><key>id</key><value>tempest_image_source_0</value></param>
<param><key>Htotal</key><value>hor</value></param>
<param><key>Hvisible</key><value>hor</value></param>
<param><key>image_file</key><value>/home/flarroca/ownCloud/facultad/cursos/taller_gnuradio/gr-taller/examples/shannon.jpg</value></param>
<param><key>repeatmode</key><value>1</value></param>
<param><key>Vtotal</key><value>ver</value></param>
<param><key>Vvisible</key><value>ver</value></param>
</block>
<block>
<key>tempest_normalize_flow</key>
<param><key>id</key><value>tempest_normalize_flow_0</value></param>
<param><key>alpha_avg</key><value>1e-2</value></param>
<param><key>max</key><value>245</value></param>
<param><key>min</key><value>10</value></param>
<param><key>update_proba</key><value>0.1</value></param>
<param><key>window</key><value>hor</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0</value></param>
<param><key>display_height</key><value>ver</value></param>
<param><key>display_width</key><value>hor</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>ver</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>hor</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>tempest_normalize_flow_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>video_sdl_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>taller_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>taller_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>taller_deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>taller_interleaver_0</source_block_id><sink_block_id>taller_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_image_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
