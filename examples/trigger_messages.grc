<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nivel</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>nivel</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>pendiente</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Positiva</value></param>
<param><key>label1</key><value>Negativa</value></param>
<param><key>label</key><value>pendiente</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>-1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>"trigger"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>taller_align_tag</key>
<param><key>id</key><value>taller_align_tag_0</value></param>
<param><key>muestras</key><value>1024</value></param>
</block>
<block>
<key>taller_trigger_tag</key>
<param><key>id</key><value>taller_trigger_tag_0</value></param>
<param><key>nivel</key><value>nivel</value></param>
<param><key>pendiente</key><value>pendiente</value></param>
</block>
<block>
<key>zeromq_req_msg_source</key>
<param><key>id</key><value>zeromq_req_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5557</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>taller_trigger_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>taller_align_tag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>taller_trigger_tag_0</source_block_id><sink_block_id>taller_align_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_req_msg_source_0</source_block_id><sink_block_id>analog_sig_source_x_0</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>zeromq_req_msg_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>zeromq_req_msg_source_0</source_block_id><sink_block_id>taller_trigger_tag_0</sink_block_id><source_key>out</source_key><sink_key>nivel</sink_key></connection>
</flow_graph>
